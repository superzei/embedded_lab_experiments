# Keil uVision project interrupts.uvproj, settings and files
target interrupts (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: interrupts
  AfterMake: fromelf --bin --output .\rvmdk\interrupts.bin .\rvmdk\interrupts.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PGE TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.4.178\examples\boards\dk-tm4c123g;C:\ti\TivaWare_C_Series-2.1.4.178
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c startup.s UART.c DFPlayer.c Drum.c SysTick.c Timer.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.1.4.178/grlib/rvmdk/: grlib.lib
